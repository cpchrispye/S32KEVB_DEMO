# Keil uVision project S32KEVB_DEMO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: S32K146UAxxxLQx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x0000F000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32KEVB_DEMO
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xf000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
